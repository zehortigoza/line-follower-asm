#INCLUDE <P16F877a.inc>

#DEFINE BANK0 BCF STATUS,RP0
#DEFINE BANK1 BSF STATUS,RP0

;INÍCIO
ORG 0x00
GOTO INICIO

;ÁREA PARA INTERRUPÇÕES
ORG 0x04
 
RETFIE


  ;DECLARAR VARIÁVEIS 
  CBLOCK 0x20

  ENDC

INICIO

   ;CONFIGURAR PORTAS
   BANK1
   MOVLW B'00011111'
   MOVWF TRISA
   MOVLW B'00000000'
   MOVWF TRISB
   MOVLW B'10001111'
   MOVWF TRISC
   MOVLW B'00000000'
   MOVWF TRISD
   MOVLW B'00000000'
   MOVWF TRISE

   MOVLW B'00000000'
   MOVWF OPTION_REG
   MOVLW B'00000000'
   MOVWF INTCON
   BANK0


   ;PROGRAMA PRINCIPAL 
   MAIN
    

END

